Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Strada 150.IFC
Time: 2022-04-28T11:53:23
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Strada 150
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
